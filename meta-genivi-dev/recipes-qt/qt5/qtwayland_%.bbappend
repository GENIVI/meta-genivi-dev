DEPENDS_append_koelsch = " libegl gles-user-module"
